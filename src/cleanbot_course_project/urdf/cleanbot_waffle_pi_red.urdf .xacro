Commit message: nb:

File: src/cleanbot_course_project/urdf/cleanbot_waffle_pi_red.urdf .xacro (robot description, xacro)
@@ -52,5 +52,5 @@
       </geometry>
       <material name="dark"/>
-    </visual>
+    </visual>1
     <collision>
       <origin xyz="0 0 0" rpy="0 0 0"/>
